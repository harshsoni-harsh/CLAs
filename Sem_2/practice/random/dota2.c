#include <stdio.h>
#include <string.h>

char * predictPartyVictory(char * senate){
    int count=0;
    int len=strlen(senate);
    char win=senate[0];
    while(count!=len)
    {
        count=1;
        for(int i=0; i<len; i++)
        {
            if(senate[i]==win || senate[i]=='a')
            {
                count++;
            }
            if(senate[i]!='a')
            {
                win=senate[i];
            }
            else
            {
                continue;
            }
            int q=0;
            for(int j=i+1; j<2*len; j++)
            {
                if(j<len)
                {
                    q=j;
                }
                else
                {
                    q=j-len;
                }
                if(senate[q]!='a' && win!=senate[q])
                {
                    senate[q]='a';
                    senate[i]=win;
                    break;
                }
            }
        }
    }
    printf("%d\n", count);
    if(win=='R')
    {
        return "Radiant";
    }
    return "Dire";
}

int main()
{
    char a[]="RRRRRDRRDRDRRDRRDDRRDRDRDDDRRRRDRRRDDRDRDDDRRRDRDRRRDDDRRRDDRDRRDRDDDRRDDRRRDDDRDRRRRRRRRRDDRDRDDDDDRRDRRDRDRDDRDDRDRRDDRDRRRDDDDDDDRRDRRRRRDRRDRRDDDRDDRDRDRRDRRDDDDRRDDRDRDRRRRDDRDRRRRRDRRDDRRRDRDRRDDRDDDDDDDDDDDRRRRRRRRDRRRDDRDDRDDDDDRDDRRDRRDDRRDDRDDRDRRDRDDDDRDDRDRDRRDDDDDRDRDRRRRDRDRDRDDRDRRRRRDRRRRDDDDDDDRDRRDRRRDRDRRDRRDRDDRDRDRDRDDDDRRRDDDDDRDDRDRRDDRDDDDRRRRRDRRRDDRDDRDDRRRRRRRDRRRDDDDRRDDDDRDRRDDRRDDDRDRRRRRDDDRRRRRDRRRRRDRDRDRRRDRRRDDDDRRRRRDRRDDRDRRRDRDDDRDRDRRRDDDRDRDRDDDRRDDDDRDDRDRRRDDRDDDRRRDRRDRRDDRDDDDDRDDDRDDDDRDRRDRRDDRRDDRRRRDDRRRDRRDRDRDDDRRRDDDDRDDDDDDRDRRDRRRDDDRDDRDRRRDDDDDDRRDRRDDRDDRDRDRDDDRDDRRRDRDDRDRRRRRDDRDRRDRRDDDDDDRDRRRRDRRRRDDRRRDDRDRDDDDRRDRDDDRRDDDRDRDDRRDRRDDRRRDRRRDRRDRRRDDRRRDDDDRRDDDRRDRRDRDRRRRRDDRRRRRRDDRRDRRDDDDRRDRDDDDDDDRDDRDDDDDRDRRRDDRRRRRDDRDDDRRDDDDDRDRDDRRRRDDDRDDRDDRDRRDDRRRDRDDRDRDRDRDRRRDDDRDRDDRDDRRDRDRDDDRRDDDRDRRRDDRDDRRRRDRRRRRDRDRRRRRRDDDRRRDRRRRRDDDDRRDRDDRRDRRRDDDDDRDDRRDRDDRRRRDRRRDRRDDDRDRRRRRDDRRRDDDRRRDRRDRDDDDDDDRDRRDRDRDRDDDDDRDRRDDRRRDDDRDRRDDDDRRRDRRDDRDRRRRDRRDDDDDDDDRRRDDDDDDDRRDRDDDDDDDDRRDRRDDDRRDRRRDRDRDRRDDDDRDDRDDDRDRRDRRDRDDDRDRDRDDDRRRDDRDRRDDRRDRRRDRDDRDDDRRRRRRDDDDRDDDDDRRDRDDRDRRRDDRRRDRRDDDDRRDDRDDRDDRRDDRDRDDDRDDDRRRRDRDDDDRDDRDRDRDRDDRRRRRDRRDDDDDDDDDDRRRDRDDRRDRDRDDDDRRDDRDRDDDRDDDDDDRDDRRRDRDDRRDDDDRDRDDRRDRRRRDRRDRRDRDRDDRDRDRRRDRRDDDRDRDDDRDDRRRDDDDRDRDDRDRRRDDRRRRDRDDDDRRDRRDRDRDRRRDRDDRRDDRDDDRDDRDDRDDRDRRRRRRRDRRDRDRRDRRRRRRRDRDDRRRDRDRDRDDDRDDDDDRRDDRRDDDRRDRDRDRRRRDDRDDRRDRRRDRDDRDRRRDRRRRDDDRRRDRDDRDDDDDRDRDDDRRRDRDRDRRDRDDDDDDRRDRRRRDDDDRDRDRDDRRDRDRRDDRRDRDRDDDDDRDDRRDDRRRDRRRDDRRDRDRDRRDDRRDRDDRRRDDRDRDDDDRRDRRRDDDDRDRRRRDRDRDRDDRRDDRDRRDDDDDRDRRDDDRDDRDRDRDRDRDRRRDDRDDRRDDDDRRRDDRDRDRDRRDRRRRDDRDDRRRRDRRRDDDRRRRRRDRDRRRRDDDRDRDRDRRRRDDRRRRRDDRRDDDRRRRRDRRRDDRDRDDDRRRDRRRRDRDRDRDRDRDRRRDDRRRRDDDDRRDRRDRDRRRRDRDDRRDRDRRDDDRRRRRRDRRRRRRRDDRDDDDDRDRDDDDDDRRRRRRDRRRRDRDRRRDRDDDRDDDRRRDDDDRDDDDRDRDDDRDRDRDRDDDDRRDRDDRDRDDRRDDDRDDDRRRDDDRRDRDDRDRDRDRRRRRDRRDRRRRDDDDDRRRDDRDRRRDDDDRRRDDRDDRRDRRDDDDRRRRRDDRRRDRRDRRRDRRRRRDRRDDDDRRDRRDDRDDRRRRDDDDDRDDDDRRDDRRRDDDRDRRDDRRDRDDRDRRRRRRRDRDRDDRRRRRRDRRRRDRDDDDRRDRDDRRDRDRRRRRDDDRRRRRRRDDDRDDDDRDRRDDRDDDRRDRRRRRRDDRRDRDDDRDDDRRRDRDDDDDDDDDRDRDRDDRRRDDDDRRDRDRDRRDDRRDDDDDDDRDRRRDRRDRRRDDDRRRRDRDDRDDRDDDRRRDDDDDDRDDDRDRDDDRDRDRRDDRDDRDRDRRDDDRDDDDRDDDRRRDRRRRRDDDRDRRDRRRDDDRDRRDDRRDRDRRRRRRDDDRRRDDDRRRRDRRRRDRDDDRDRRRRRDRDRRRDDRRRDDRRRRDRDDDRRRRDRDRDRDRRDDRRDDDDRDDDDDRRRDRDRRRRRRRDRRRRRRDRDRDRRRDDRRRDDDDRDDRDRDRDRDRDRRDRDRDRDDRRRDRRDRDRRRDRDRRRRRRRRRDDDRDDRRDRDRRRRDRDDRRRRRRRRRRDDRDDRRRRDRDDRDRRDDDRDDRDRRDRDRRDDRDDRDRDRDRRDRDRRDDRDRDDDDDRDRRDRDDRDRDDRDRRDDDDDRRRDRDDRRRDRRRRDRDDRDRDDRRRRRDDRDRRDRDDDRRRRRRRRDRRRDDRDRDDDRDRDDDRDDDDRRDDDDRDDRRDDDDRRRDRRDDRDRDDDRDDDRDDDDDDDDRRRRRRDDRRRRRRRRDRDRDDDDDDDRDRRDDDDRDRRRRDRDRDRRRRRRDDDRDDRDRRRRDRRRDDRDRDDDDRRRRDDDRDRRDDDRRRRDRRDRDDDDDDRRRDDDRDDRRRRRRDRDRDDRDDDRDDDRRDDRDRDRDRDDDRDRDDDRDRDDDRDRRRRRDDDDRRDRRDDRDRDDDRDDRDRDRDDDDDRRRRDDRRRRDRDDDRDRRDRRRDRDDDDDDDDRRDDDDRDRRDDDDRDDRRDRRRRRDRRDRRDDRRDDDRRRRDDDRDRRRRRDDDRRRDDRRRDRDRDDDDRRRRDDRRDRDDDRRRDDDRDRRRDDDDDRRRDRDRDDDDDRDDDRRDRDRDRRRRRDDRDDRDDDRDDRRDRDDDDRRDDDRDDDRRRRDDDDRRDDDRDRDDDRDRRDRRDRDRRDRRDRDRDRDDRRRDDDRDDRRDDDRDDRRRDDDRRDRRRDDRDDDRDRRDDRDRRDDDRRDDRRRDRDDDRDDDDRDRDRDDDDDRDRDRRDRDRDRRRRRDRRRRRRRDDRRRDDRRRRRRRRDDDRRRRDRRRRDRDRRDDRDDRDDRRDDDRRDRRDDDDDDDDRDRDRRDDDDRDDDRRRRRDDDDDRDRDDDDDDDDRDRDDDRDRRRDDDDRRRDRDDRDRDDDRDDDDDDRRRRDDRDRDDRRDDDRDDDDRRDRDRDDDRRDDDDRRRDRDRDRRRDDDRDDRRDRRDDRRDRRDDRRDDRRRRDRRRDDRDDDDDDRRRDDDRDRRDRRDDDRRDRDDRDDRRDRRRDDRDRDDDRDDDDRDDDRDRRDDRDRDDDDDRRDDRRDDDDDDRRRRDRDDRDDRRRRDRRDDDRDDRRRRRRDDDRRRRDDDRDDRDDRRRDRRRRDRDDRDRDDRRRRDRDDRDDRDDDDDRRDRRRRRDRRRDRDDRDRRRRDRRDDDRDRDDDRDDDRDDDRRRRDRRDDRDDDRDDRDDRRRDDRDRDRRRRRDDRDRRDRDRRDDRRDRDRDDRRDRDDDRRRRDRDDRDDDDRRRRRDDDDDDRRDRDRRRDDRDDDRRDRDDDRRDRRDRDRDDDDDDDRRDDRRDDDRDRDRRDDDDRDRDDDRDRDRDRRDRRDRRRDRDRDRRRDRRDRDRRRDRRRRDDDDRDRDRRRRDRDRRRDRRRRDDRDDDRDDDDDDRDDDDRDRRDDDRDDDRRRDRDDDRRDDRDRDRRDRDRRRDRRRRRRDRRRDRDRDDRRRRDRRDRDDDDRRDDDDDDDDRDRDRRRRDRDDDDDRDDRRRDRDRDDDRDRRRRRDDDDDDRRDRRDRRDDDRRRRDRRRRDDDDDRDRRDRDRRDDRDRRRDRDDRRDDRDRRRRRRDRDDDRDDRDRRDDRDDRRRRRDDRRRDDDDRRDRDRDRRDDDDRDRRRRRRRDRDDDDDRDRRRDDRDRDDRRDDRDDDRRDRRRRRRDRRDDDRRRRRRRDRDDDRRRRDRDDDDDRRRDDDRRDRRDDDDRDDRRRDDRRRRDDRDRDDDDRDDRRDDDRDRRDDDRRDDDRDDRDDRDDDDRDRDRRRDDRDDRDRRDRRDDDDRDDRRRDDRDDRDDDRRRDDDDRDDRRDRDDDDRRRRDRDRDDDDRRDRRRRRDRDRRDRDRRRDDRRRDDRRRDDRRRDDDRRDRDDRDDDRDRDDRRDRRRRRDDDRRRDDRRDRRRDRDDRDRDDDRRDRRRRDRRDDRRRRDRDRRDRRDRDDRDDDDDRRDRRDRRDRRRDDRDRRDDDDRDDDDRDRRDDRDRRRDDRRDRRRDRDDDDDRRRRDDDRRRRDRRRRDRDDDDDDDDDRDDDDDDRDRRDRDDDDRRDDRRRDDDDDDDDDDRRDRRRDDDDRDDDDDRDDDRRRDRRDRRRDRRDDRRRDRDRRRRDRDDRRDDDRRDDDDRDRDRDDDRRDDDDDRDRDDRDDRRDDDRRRRRRRRRDRDDRDRDRRDDRRRDDDRRRRDRRRRRRDDDRRRRRRRRRRRRRDRDRDRRDDRDRDDRRRRDDRDDRDRDRRRDDDDRDRDDDRDRDRRDDDDRRDRDDDRRDRRRDRDRRRRDDRDDDDRDDRDDRDDRRDRDRDDRDRRDDRDDDDDRRDRDRDDRRDRDDDRDRDDDRDDRDRDRDRDDDDDDRRRDRDDDDRDRDRRDDRDDRRRRDRDRDRDRDDRRDDRRRDDRRRRDRRRDDRDDRRDDRDDRRRRDRRDRDDRDDDDDDDRRRRDDRDDRRRRRRRRRRDDRRDDDDRDDDDRDDDDRRDRRRDDRRDDDDRDDRRDDDRDRDRDDDDDRRRDRDDRRDDRDRDRDRRDDDDDDRRRDRDRDDDDRRDDRDDRRRDRDDDRRDDRDRRDDRRRRDDDDRRRRDDDRDDDDRDDRDDRDRDRDRDDDRRRRRDRRDRDRRDDDDDDDRRDRRDDRRDDDRDRDDRRDDRRDRRRRRRRDDDRRRRDDRRDRDRRDDDRRRRDRRRDRRRRRRRDRDDDDRRDRDDRRDRRDDDRRDDRRDRDRDRRRRDRRDDRDDDDDRDRRDDRDDRRDDRRDDDRDDRDDDRDDDRRDRDDDDDRDDRDDDDRDDRRRRDRDDDRRRRRRRDRRDRRDDDDDRRDRDDRDDRDDRDRRDDRDRRDDDDRRRDRRRRDDRDRRRRRRDRDRRDDRDDRRRDRDDRDDRRRRDDDDDDRRRDDRDRRDRDRRRDRDRRRRRDDDDDDRRDDRDRRDDDRDDDDDRDRRRDRDDDDRRDRDRRRDDDRRDDDRDRDRDRRRDRDRDRDRDRRDDDDRDDRDDDDDRRDDDDRRRDDDRDDDRRDRDDRDDDDDDRRRDDRDDRRDRRDDDDDDRRDRRRDDDDRRRDRDRDRDRRRRDDDDDDRDDDDDRDDRDDRDDDDDRRDDDRRDDDRRDDDDRDDDRDRRDRRDRDDRDRRRRRDDRDDRDRDDDDDDDRRDDDDRRRDRDRRDDRRRRRRDDRDDRRRDDDDRDDDDDDRDRDDRDDDRRDDRRRRDDDRRRRDRRDDRRRRRDDDDDDRDDDDRDRRRRDDDRRRRRDDDDDDRRRDRDDRRDRDDDDRDRRRDDDDDRDRRRRDDDRDDRDDDRRDRDRRRRDRDRDDDDDDDRDDDRRDDRDRRDDRRDDDDRDRRDDRRRDRDDDDDRRDRDRRRRDDRRRDDRDRRRDRDRRDDDRRDDRDRDRRRDDDRRRRDDRDRDDDDRDRRRRDDRRRRRRRDRDDDRRRRRRRRRRRDDRRRDRDRDRDDDRRRDRRRDRRDDRRRDDDRRRDRDRDDRRDDRDRDRRRDDDDDRRDDDDDRRRDRRDRDDDDRRDDRDDRDRDDDDDDDRRRDDRRDDRDRDDRDRRDDRRRRDRRDDDDDRDRRRDDRDDRDDDDRRRDRRRDRDRRRDRRDRRRRRRDRDDRDDRDRRRDDRDDDDDDDDRDRRRRDDRRRDRDRDRDRDRDRDDDDDDRRDRDDDDDDRDRDRDDRDDRDDRDDDRRDRDRDRRRRRDDDDDRRRRDRDRDDDRRDDDDDDDRDDDDDDRRRDDRDRRRDDDDRRDRRRDRRDDDDDRDDRRRDDDRRDRDDRDRRRRRDRRRRDDDRDDDRDRRRRRDDDRRDRDDDDRDRDRRRDDRDDRRRRDDDDRDRDDDRDRRDDRDRDRRRDRDDRRDDRRRRRDDDRRRDRDRDRDDDRRDDDDRDRRRDDRRDDRDDRDRRRRRRDRRDDRRDRDRDDDDDDRRDDDRDRRDRDRRRDRDDDRRDDDDDDDRDRRDDRRRRDDRRRDRDRRRRRRRDDDRDRDDDDRRRRDDDDRDRDRRDDRDRDRRDRDDRRRRDRRRDDRRRDDDRRRDRRDRRRDRDRDDRDRDDDDRDDRRRDRDRDDRDRDDRRRDRRDRRDRRDDDDRRRDDDDRDDDDDDDDDDRRDDDDRDDRDRRDRRDDDDRRRDDDDDDRDDRDDRDDRRDRRRRRRRRDRRDDDDDDRDDRDRRRRDRRDRRDDRRDRRDDRDDDDDDRDRRRRDRRDRDDRDDDRRDDDDRRRDRDRDRRRRRRDDDDRDDRRDRRRDDDRDDDDDDDRRDRDRRDRRRDRDDRDDDDDDRDRRRDRRRDDDDRRDRDRRRDDRRRRDDDRRDRDRDRRRDRDRDDRRDRRRRDDRDRRDDRDDDRDDRDDDDRDDRRDDRDRDDDDRRDRRRRDDDDRRDRRDRDRDRDRRRRRRDRDDRDDDDDRRDRDRDDDDDDRRRDDDDRRDRRRDRRRRRDRDDRDDDRRDDRRRRRRDDDDRRDDRDRDDDDRRRDDRRDRDDDRRRRDDDDRDDDRDDDRDRRRRDRDRDRDDRDRDDRDDRDRRRDRDRRDDRRRRRDDRDDDDDRDRRRDDRRRRDDRDDDDRDRRRRDRDRRRRRRRDRRDDRRDDDDDDDRRRRDRDDDDDRRRDRDRRDRDRRRDDRDRRRRRRRDRRRRRRRDDRDDRDDDDRRRDRDRRDDDDRRDRDDRDDDDRRRDDRDRRDDDDDDRRRRRRDRRRDDRRRRRRDDDRRRRRDDRDDRDRRDRRRRDRRDRDDRDRRDRRDRRDRDRDRDRRDRDDDRRRRRDDDRDDRDRDDRRDRRRRRRRDDRRRRRDRDDRRRRRRDRDRDRRDRDDRRDDDRRRDRDRDDDRDDDDDRRDRDRRDRRRRRRRDDDDRRRRDRRDDDRDRRDDDRDRRDDRRRRRDDRDDDDRRRDRRDDRDRRRRRRRDDRDDDDDRRDDDDDDDRRDDDDDDDDRDRDDDDDDDDRDRRDRRDDDDDDDDRDRRRDDRRDRDDRRDRDDDRRRRRRDRDDDRDRDDDRDRRRRDRRDDDDDDDDDDDRDDRDDDRDRRDRRDDRRRRDDDDRRRDRDDRDRRDDRRRRDRRDDRRRDDRRDDRRDDRDRDRDDDRDDRDDDDDRDRRRRDRDRRDDRDDRRRDRDDRDRDDDRRDRDDDRRRDDRRDRDRDDRDDDRRDRDDRDRRDRDDDDDRRRDDRDRRDRDDDDRDRRDRRDRDRRDDDDRDDDRDDDRRRDDDRRRRDDRRRDRRRDRRRRRDRDDDDDDRDRRDDDDRDDRRDRDRDDRRRRDRRDDDRDDDDRRRRRRRRDRDRDDRRDRRRDRDRDRDRRDDRRDDRDDDRDRRRDDDDDRRRRDDDDRDRRDDRRRRDRDRRDRDRDRRDRDDDDRRRRRRRDDRRDRDDRDDDRRRDRRDDDRRDRDRDDDDRDRDRRDDRRDDRDDRDDDDRDDDRDDDRDDRRDRDRRDDRDDDDRDDDDDDRRRDDDDDRDDRDRDDRDRDDRRDRRRDRRDDRRDRRDRDRDDDRDRRDDRRRDRDRRDDRRRDRRRDRRRDDRRRDDRRDRDDDRRRDDRRRRDRRDDDRDDRDRRDDDRDDDRRDDRDDDDRRRRDDDRDRDDRRRRRRDRRDRDDRRRDDRRRDRRDDRDRDDDDDRRRRDRRDRDRDDDRDRDDRDRRRDRDRDDDDDDRRRRDRRRRDDDDRDRDDRRRRRDRRRRRRDRRDDDDRRDRRRDRDRRDDRDDRDDDDRRRDRDDRDRRDRRDDDRRRDDRRDDRDDRRRDRRDRDDRDRDDRDDRDRDRRRRDDRRDDDRRDDRDRDRDDRRDRDRDDRDRRRRRRRRDDRRRDDRRRDRRDRRDDRRDRRRDRDDDDRRDRRDRDRDDDDDDDDRDRDDDDRDDDRDRRRDDRDRRRDDRRRRRDDDRDRDDDDRRDDRDDRDRDDRDRDRRRDDRRDRDRRRRRRDRDDRDRDRRDRDRDDRRRDDRRRRRRDRDDDDRDDDRRRDRRRRRDRDRRDDDRDRDRDDRRRDDRDRRDDRRDRDRRDDRRRRDRRRRDRDRDDDDRDDDDDRDDRRDDRDRRDRDDDDDRDRRDRRRDRDRRRRDRDDDRRRDRRDDRRRDDDRDRRRDDRDDRDRDDDRRDDDDRRRDRRDDDDDRDRRRDDRRDDRRDDDRRRDRRDDDRDRDDRRDDDRRDRDDRDDDRDDRDRRRDRRDDDRDRDDRRRDRDDRRDRDRDDDRRDDRDDRDRRRRDDRRDRDRDDRDRRRRRRDDRRDRDDDRRRRRRDDDRDDRRRDDDRRRDRDRRDDDDDRDDDRRDDRRDDRRDDDRRDRDDDDDDDDDRDRDDDDDDDRRDRDRDRRRRRRRDRDRRDRRRRDRRRDDDDRDDDDDDDRDRDRRDDDDDRDDDRRDDRDDDRRRDDDRDRDRDRDRRRRDDDDDRDDRRDRDRRRDRDRDRRRRRRDRDDDDRRRDDDRRDDRDDDDRDRDRDDRRDDDDRRDDDRDRRDDDDDDDRRRRDDRDDRDDDDRDDDDDRDDRRDDDRRRRRRRDDDDRDRDDRRDRDRRDRDRRDDRRDDDDRRRRRRDDDDDRRRDRRRDDDDDRRDRDRDRRRRRRRDDDRRDDRRDRDRDRRRDDRDRRDDDRRDRRDDRRDRRRRDRDRDRRRRRRRRRRDRDRRRRRDRDDRDDRDDRRRRDRRDRDDRDDDDRDDDRRDDRDDRRDDDDRDRRDRDDRRDDDRDDDDRDRDDDRRDRDRRRDRRDDDRDRRRRDDDRRDRDRRDDRDRRRRRRRDDDRRDRDDRDDDRDDRDDDDRRRRDDDDRRDRDRRRRRDRRRRDDDRRDDRDDRDRDRRRRRDDRRDRDDDDDDRDRDDRRDDRRRRRDDRDRRDRDDDDDDRDRRRDRDDRDDRRDRRRDRRRRRDDRDDRRDRDDRDDRDRRRDRDRDRDRDRRRRDRDRDRRDRDRRRDRDDRRDRRRRDDRRRDDRDRRDDDRRDRRRRDRDRDDDRDDDDDDRRDDDDDDDDRDDDRDDRDDDRRDRRDDDRDRRRDRDRRRRDDRRRDDRRDDRDRDDDDRRRRRRRDDRDDDDDDDRDDRRRDDRDDDRDRDRRDDRRRDRDRDDRDRDRDRRRRRRDRRDDRRDDDRRRDRRRDDDRRDRRRDRRRDRRRRDDDRDDDRDDRDDRRDRDRDRDDDDDRRDRRDDRDDRDRDRRRRRRRDDDDRDRDRRRRDRRRDDRRDRDDRDDRRRRRRRDDDDRRRRDRRRRDDDDDRDDDDDDDDDDDDDRRRRDRDDDDRRRDDRDDRDDRDDRRRRRRDDRDRDRRDRDDRRRRRDRDDDDDRRRDRRDRRRRDRRDDRDRDRDDRDDRDRRDRDDDDDRDDDRRDDDDDRDDDDRDRRRDDDDDRRDDRDRDDDRDRRDDDRDRDRDRRRDDRRDDRRRRDRDDDRRDDRDDDRRDDDRDDDDDRRDRRDDDRRRDDRRDRRRRDDDRRDDDDRDRRRRDRRRDRDRDDRDRRDDDDDRDRDDDRDRRRRDDDDDDRRRDRRRDRRDRRDRDRDDDDDDDRDDDRDRDRDDDRRRDRDRRDRDDRDRRRRRDRDRDDRRDDR";
    // printf("\nHello World \n %ld ", strlen(a));
    printf("%s\n", predictPartyVictory(a));

    return 0;
}
